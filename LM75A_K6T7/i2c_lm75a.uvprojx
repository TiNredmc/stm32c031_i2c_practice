# Keil uVision project i2c_lm75a.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32C031K6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: i2c_lm75a +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src_drv
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group src_main
    ./src_main/: main.c
  group src_drv
    ./src_drv/: clk.c clk.h systick.c systick.h i2c.c i2c.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
